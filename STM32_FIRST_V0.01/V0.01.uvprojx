# Keil uVision project V0.01.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V0.01
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group v0.01
    ./: main.c SYSTEM.c SYSTEM.h LCD.c LCD.h ADC.c ADC.h PWM.c PWM.h UART.c UART.h INTERRUPT.h INTERRUPT.c TIMER.c TIMER.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
